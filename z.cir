% Netlist dump from 04-Nov-2015 17:19:05
R1 1 0 1.000000
R2 2 1 1.000000
R3 3 1 1.000000
R4 2 0 1.000000
R5 3 2 1.000000
R6 3 0 1.000000
I1 1 0 1.000000
