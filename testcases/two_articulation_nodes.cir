% Given terminals in nodes (1, 5) we should reduce node 3.
R1 1 0 999999999999
R1 1 2 1
R2 2 4 2
R3 2 3 1
R4 3 4 1
R5 4 5 1
