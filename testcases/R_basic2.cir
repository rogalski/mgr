%Chain of resistors with single ground
R1 1 0 10
R2 2 1 0.01
R3 3 2 0.01
R4 4 3 1
R5 5 4 10
