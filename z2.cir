% Netlist dump from 06-Nov-2015 00:00:55
R1 1 0 1.000000
R2 2 1 1.000000
R3 3 1 1.000000
R4 2 0 1.000000
R5 3 2 1.000000
R6 3 0 1.000000
